require embms-kernel.inc

COMPATIBLE_MACHINE = "sdxprairie"

S = "${UNPACKDIR}/kernel/msm-4.14/net/embms_kernel/"
