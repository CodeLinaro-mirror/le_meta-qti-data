require embms-kernel.inc

COMPATIBLE_MACHINE = "sdxlemur|sdxnightjar"

S = "${WORKDIR}/kernel/msm-5.4/net/embms_kernel/"
