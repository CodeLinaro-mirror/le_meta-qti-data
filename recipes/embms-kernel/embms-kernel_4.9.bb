require embms-kernel.inc

COMPATIBLE_MACHINE = "sdxpoorwills|sdx20"

S = "${WORKDIR}/kernel/msm-4.9/net/embms_kernel/"
