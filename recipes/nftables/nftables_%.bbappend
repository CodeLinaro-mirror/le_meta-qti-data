# readline is GPL-3.0-or-later, which is blocked by the nogplv3 distro policy.
PACKAGECONFIG:remove = "readline"
