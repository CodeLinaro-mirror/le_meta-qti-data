require dnsmasq.inc


SRC_URI[dnsmasq-2.90.md5sum] = "23a767c3a6797d20492d06d352fd926b"
SRC_URI[dnsmasq-2.90.sha256sum] = "8f6666b542403b5ee7ccce66ea73a4a51cf19dd49392aaccd37231a2c51b303b"

