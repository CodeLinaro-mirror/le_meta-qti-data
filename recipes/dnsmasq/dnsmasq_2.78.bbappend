#Copyright (c) 2017, Linux Foundation. All rights reserved.
#Linux Foundation chooses to take subject only to the GPLv2
#license terms, and distributes only under these terms.
