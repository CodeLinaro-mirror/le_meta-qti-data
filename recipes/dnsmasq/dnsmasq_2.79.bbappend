#Copyright (c) 2018, Linux Foundation. All rights reserved.
#Linux Foundation chooses to take subject only to the GPLv2
#license terms, and distributes only under these terms.
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://CVE-2020-25681.patch"
