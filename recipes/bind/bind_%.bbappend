RDEPENDS_${PN}_remove = "bash"
RDEPENDS_${PN}-utils_remove = "bash"
