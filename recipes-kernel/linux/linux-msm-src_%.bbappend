# Apply kernel config fragment required by qca-nss-ecm module.
require linux-kernel-ecm-cfg.inc

# Apply kernel config fragment for data layer netfilter features.
require linux-kernel-data-netfilter-cfg.inc
