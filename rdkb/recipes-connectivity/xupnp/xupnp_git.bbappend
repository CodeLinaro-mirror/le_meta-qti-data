PACKAGECONFIG:remove = "gupnp0.2-dfl"
PACKAGECONFIG:append = " gupnp0.2"

CFLAGS:append = " -Wno-old-style-declaration"
