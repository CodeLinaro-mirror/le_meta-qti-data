# Disable websocket support in mosquitto
PACKAGECONFIG:remove = "websockets"