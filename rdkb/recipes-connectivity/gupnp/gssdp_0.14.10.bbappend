LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

inherit autotools pkgconfig
DEPENDS = "glib-2.0 libsoup-2.4"
