FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://00001-rdk-logger_timestamp_Fix.patch \
"
