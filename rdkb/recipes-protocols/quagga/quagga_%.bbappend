FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += " \
   file://00001-quagga_Ipv6_prefix_client_management.patch \
"
