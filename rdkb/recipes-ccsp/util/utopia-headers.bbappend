FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append += "file://00001-qti-utopia-headers-firewall_black_white_list.patch \
                  "
