FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://00001-qti-ccsp-common-library-coredump-fix.patch"
