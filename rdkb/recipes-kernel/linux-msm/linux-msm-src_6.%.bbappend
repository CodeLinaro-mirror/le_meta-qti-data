FILESEXTRAPATHS:prepend := "${THISDIR}/files:${THISDIR}/patches:"

SRC_URI += " \
    file://00001-qti-linux-msm_nf-conntrack-sip-fix-sysctl-table.patch \
"
